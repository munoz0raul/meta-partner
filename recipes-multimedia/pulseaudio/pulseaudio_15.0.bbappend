FILESEXTRAPATHS:prepend := "${THISDIR}:"

GROUPADD_PARAM:pulseaudio-server:qcom = "-r pulse"
